# Keil uVision project ST7735.uvprojx, settings and files
target ST7735 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: ST7735 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F30X, USE_STM32303C_EVAL
  c include: ..\src;..\..\STM32F3_Libraries\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\STM32F3_Libraries\Utilities\STM32F3_Discovery;..\..\STM32F3_Libraries\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group MDK-ARM
    ../../STM32F3_Libraries/Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group STM32F3X_Discovery
    ../../STM32F3_Libraries/Utilities/STM32F3_Discovery/: stm32f3_discovery.c
  group STM32F30x_StdPeriph_Driver
    ../../STM32F3_Libraries/Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_crc.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c
  group src
    ../src/: stm32f30x_it.c Adafruit_ST7735.c DefaultFonts.c hw_config.c main.c
    ../../STM32F3_Libraries/Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
